# Keil uVision project TriLED_blink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MB9BF568N Spansion
  cpu: IRAM(0x20038000-0x20047FFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) IROM2(0x200C0000-0x200C7FFF) CLOCK(4000000) CPUTYPE("Cortex-M4") FPU2
  output: TriLED_blink
  c flags: Optim=1
  c include: .\WyzBee_gpio;.\common;.\lib\inc;..\..\..\Libraries\Libraries\WyzBee_oled;..\..\..\Libraries\Libraries\WyzBee_timer;..\..\..\Libraries\Libraries\WyzBee_adc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20038000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: startup_mb9bf56x.s
  group WyzBee_gpio
    ./WyzBee_gpio/: WyzBee_gpio.c wiring.c timetick.c variant.h variant.cpp
  group App
    ./: main.c
  group common
    ./common/: pdl.c system_mb9abxxx.c
  group WyzBee_oled
    ../../../Libraries/Libraries/WyzBee_oled/: glcdfont.c Adafruit_GFX.h Adafruit_SSD1351.h binary.h license.txt pgmspace.h README.txt SPI_OLED.h
  group WyzBee_adc
    ../../../Libraries/Libraries/WyzBee_adc/: WyzBee_adc.c WyzBee_adc.h
  group WyzBee_timer
    ../../../Libraries/Libraries/WyzBee_timer/: WyzBee_timer.c WyzBee_timer.h
